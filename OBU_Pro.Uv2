### uVision2 Project, (C) Keil Software
### Do not modify !

Target (OBU_Pro), 0x0000 // Tools: 'MCS-51'

Group (Main)
Group (Head)
Group (ASM)

File 1,2,<.\OBUMAIN.ASM><OBUMAIN.ASM> 0x0 
File 1,5,<.\readme><readme> 0x0 
File 2,5,<.\C_Issue.inc><C_Issue.inc> 0x0 
File 2,5,<.\CardAPP.inc><CardAPP.inc> 0x0 
File 2,5,<.\CC1101.inc><CC1101.inc> 0x0 
File 2,5,<.\COMMON.INC><COMMON.INC> 0x0 
File 2,5,<.\Contact.inc><Contact.inc> 0x0 
File 2,5,<.\DSRC.INC><DSRC.INC> 0x0 
File 2,5,<.\GSM.inc><GSM.inc> 0x0 
File 2,5,<.\HDLC.INC><HDLC.INC> 0x0 
File 2,5,<.\LCD.INC><LCD.INC> 0x0 
File 2,5,<.\LIB.INC><LIB.INC> 0x0 
File 2,5,<.\MFCard.inc><MFCard.inc> 0x0 
File 2,5,<.\NContact.INC><NContact.INC> 0x0 
File 2,5,<.\NotContactCard.inc><NotContactCard.inc> 0x0 
File 2,5,<.\OBUMAIN.INC><OBUMAIN.INC> 0x0 
File 2,5,<.\ProCard.inc><ProCard.inc> 0x0 
File 2,5,<.\SERIAL.INC><SERIAL.INC> 0x0 
File 2,5,<.\TEST.INC><TEST.INC> 0x0 
File 3,2,<.\TFT_LCD.asm><TFT_LCD.asm> 0x0 
File 3,2,<.\TEST.ASM><TEST.ASM> 0x0 
File 3,2,<.\SERIAL.ASM><SERIAL.ASM> 0x0 
File 3,2,<.\ProCard.asm><ProCard.asm> 0x0 
File 3,2,<.\NContact.asm><NContact.asm> 0x0 
File 3,2,<.\MFCard.asm><MFCard.asm> 0x0 
File 3,2,<.\LIB.ASM><LIB.ASM> 0x0 
File 3,2,<.\HDLC.ASM><HDLC.ASM> 0x0 
File 3,2,<.\GSM.asm><GSM.asm> 0x0 
File 3,2,<.\flash.ASM><flash.ASM> 0x0 
File 3,2,<.\DSRC.ASM><DSRC.ASM> 0x0 
File 3,2,<.\Contact.asm><Contact.asm> 0x0 
File 3,2,<.\CC1101.asm><CC1101.asm> 0x0 
File 3,2,<.\CardAPP.ASM><CardAPP.ASM> 0x0 
File 3,2,<.\C_Issue.asm><C_Issue.asm> 0x0 


Options 1,0,0  // Target 'OBU_Pro'
 Device (STC11F60XE)
 Vendor (STC)
 Cpu (IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2)
 FlashUt ()
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 DevID (54142)
 Rgf (STC12C5A60S2.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿSTC\)
 OrgReg (ÿSTC\)
 TgStat=16
 OutDir (.\)
 OutName (51_OBU_Keil)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 MODEL5=0
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=624
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,0,240,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,4,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21630224
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DP51.DLL)(-pDR8051)(S8051.DLL)()(TP51.DLL)(-p51)
  OPTDBG 48125,-1,()()()()()()()()()() ()()()()
 FLASH1 { 1,0,0,0,0,0,0,0,255,255,255,255,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

